# Keil uVision project Projekt3-5.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projekt3-5
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: adc.c adc.h CAN_AcceptanceFiltering.h CAN_AD_L3_5_main.c can_api.c emb1_can_labs.h font.h Font_24x16.h GLCD.h GLCD_LPC1700.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
